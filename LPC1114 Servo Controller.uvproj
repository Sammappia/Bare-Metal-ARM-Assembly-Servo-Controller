# Keil uVision project LPC1114 Servo Controller.uvproj, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lab6
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  asm include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./src/: startup_LPC11xx.s main.s TMR16B1_Init.s TIMER16_1_IRQHandler.s PWM_init.s PIOINT0_IRQHandler.s SystemInit.s LCD_send.s LCD_control.s LCD_reinit.s LCD_init.s Keypad_init.s movemotor.s printNumber.s printText.s divide.s delay.s
    ./inc/: LPC11xx.inc
